# Keil uVision project game.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: game
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c buttons.h ping_pong_game.h usart.h usart_connection.h SPI.h usart_timer.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
